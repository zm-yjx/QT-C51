# Keil uVision project DS18B20小学期.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DS18B20小学期 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ds18b20.h delay.h lcd1602.h lcd1602.c onewire.c onewire.h main1.c ds18b201.c
